## zmk/app/dts/bindings/behaviors/zmk,behavior-unicode.yaml
```yaml
# SPDX-License-Identifier: MIT
description: Unicode behavior
compatible: "zmk,behavior-unicode"
include: one_param.yaml
```
